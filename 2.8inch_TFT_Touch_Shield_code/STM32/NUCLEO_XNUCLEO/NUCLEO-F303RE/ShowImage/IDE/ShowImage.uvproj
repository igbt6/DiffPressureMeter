# Keil uVision project ShowImage.uvproj, settings and files
target ShowImage (ARM-ADS)
  device: STM32F303RE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ShowImage +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F303xC
  c include: ..\SRC\Libraries\Delay;..\SRC\Libraries\Fonts;..\SRC\Libraries\LCD;..\SRC\Libraries\SPI;..\SRC\Libraries\STM32F30x_LIB\inc;..\SRC\Libraries\STM32F30x_LIB\CMSIS;..\SRC\LIB_Config;..\SRC\PF_Config;..\SRC\USER;..\SRC\Libraries\FATFS;..\SRC\Libraries\SD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../SRC/USER/: main.c fatfs_storage.c
  group PF_Config
    ../SRC/PF_Config/: PF_Config.c
  group LIB_Config
    ../SRC/LIB_Config/: LIB_Config.h MacroAndConst.h
  group Hardware
    ../SRC/Libraries/Delay/: delay.c
    ../SRC/Libraries/Fonts/: Fonts.c
    ../SRC/Libraries/LCD/: LCD.c
    ../SRC/Libraries/SPI/: SPI.c
    ../SRC/Libraries/SD/: MMC_SD.C
  group STM32F30x_LIB
    ../SRC/Libraries/STM32F30x_LIB/CMSIS/: system_stm32f30x.c startup_stm32f30x.s
    ../SRC/Libraries/STM32F30x_LIB/src/: stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_rcc.c stm32f30x_spi.c stm32f30x_syscfg.c
  group FATFS
    ../SRC/Libraries/FATFS/: diskio.c ff.c
