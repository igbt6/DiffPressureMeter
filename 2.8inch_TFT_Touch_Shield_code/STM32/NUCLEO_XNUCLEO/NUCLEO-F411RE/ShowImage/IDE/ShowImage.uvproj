# Keil uVision project ShowImage.uvproj, settings and files
target ShowImage (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ShowImage +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx
  c include: ..\SRC\Libraries\Delay;..\SRC\Libraries\Fonts;..\SRC\Libraries\LCD;..\SRC\Libraries\SPI;..\SRC\Libraries\STM32F4xx_LIB\inc;..\SRC\Libraries\STM32F4xx_LIB\CMSIS;..\SRC\LIB_Config;..\SRC\PF_Config;..\SRC\USER;..\SRC\Libraries\FATFS;..\SRC\Libraries\SD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ../SRC/USER/: main.c fatfs_storage.c stm32f4xx_it.c
  group PF_Config
    ../SRC/PF_Config/: PF_Config.c
  group LIB_Config
    ../SRC/LIB_Config/: LIB_Config.h MacroAndConst.h
  group Hardware
    ../SRC/Libraries/Delay/: delay.c
    ../SRC/Libraries/Fonts/: Fonts.c
    ../SRC/Libraries/LCD/: LCD.c
    ../SRC/Libraries/SPI/: SPI.c
    ../SRC/Libraries/SD/: MMC_SD.C
  group STM32F4xx_LIB
    ../SRC/Libraries/STM32F4xx_LIB/CMSIS/: system_stm32f4xx.c startup_stm32f401xx.s
    ../SRC/Libraries/STM32F4xx_LIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c
  group FATFS
    ../SRC/Libraries/FATFS/: diskio.c ff.c
