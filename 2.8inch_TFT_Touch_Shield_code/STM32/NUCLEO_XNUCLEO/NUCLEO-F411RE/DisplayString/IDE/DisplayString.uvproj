# Keil uVision project DisplayString.uvproj, settings and files
target DisplayString (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DisplayString
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx
  c include: ..\SRC\Libraries\Delay;..\SRC\Libraries\Fonts;..\SRC\Libraries\LCD;..\SRC\Libraries\SPI;..\SRC\LIB_Config;..\SRC\PF_Config;..\SRC\USER;..\SRC\Libraries\STM32F4xx_LIB\inc;..\SRC\Libraries\STM32F4xx_LIB\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ../SRC/USER/: main.c
  group PF_Config
    ../SRC/PF_Config/: PF_Config.c
  group LIB_Config
    ../SRC/LIB_Config/: LIB_Config.h
  group Hardware
    ../SRC/Libraries/Delay/: delay.c
    ../SRC/Libraries/Fonts/: Fonts.c
    ../SRC/Libraries/LCD/: LCD.c
    ../SRC/Libraries/SPI/: SPI.c
  group STM32F4xx_LIB
    ../SRC/Libraries/STM32F4xx_LIB/CMSIS/: system_stm32f4xx.c startup_stm32f401xx.s
    ../SRC/Libraries/STM32F4xx_LIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c
