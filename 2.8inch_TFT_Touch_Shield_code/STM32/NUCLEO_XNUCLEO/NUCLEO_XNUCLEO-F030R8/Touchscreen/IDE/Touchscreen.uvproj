# Keil uVision project Touchscreen.uvproj, settings and files
target Touchscreen (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Touchscreen
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F030
  c include: ..\SRC\Libraries\Delay;..\SRC\Libraries\Fonts;..\SRC\Libraries\LCD;..\SRC\Libraries\SPI;..\SRC\Libraries\Touch;..\SRC\Libraries\XPT2046;..\SRC\Libraries\STM32F0x_LIB\inc;..\SRC\Libraries\STM32F0x_LIB\CMSIS;..\SRC\LIB_Config;..\SRC\PF_Config;..\SRC\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ../SRC/USER/: main.c stm32f0xx_it.c
  group PF_Config
    ../SRC/PF_Config/: PF_Config.c
  group LIB_Config
    ../SRC/LIB_Config/: LIB_Config.h MacroAndConst.h
  group Hardware
    ../SRC/Libraries/Delay/: delay.c
    ../SRC/Libraries/Fonts/: Fonts.c
    ../SRC/Libraries/LCD/: LCD.c
    ../SRC/Libraries/SPI/: SPI.c
    ../SRC/Libraries/Touch/: Touch.c
    ../SRC/Libraries/XPT2046/: XPT2046.c
  group STM32F0x_LIB
    ../SRC/Libraries/STM32F0x_LIB/src/: stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_syscfg.c
    ../SRC/Libraries/STM32F0x_LIB/CMSIS/: system_stm32f0xx.c startup_stm32f030.s
