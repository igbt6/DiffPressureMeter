# Keil uVision project ShowImage.uvproj, settings and files
target ShowImage (ARM-ADS)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ShowImage
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L053xx
  c include: ..\SRC\Libraries\Fonts;..\SRC\Libraries\LCD;..\SRC\Libraries\SPI;..\SRC\Libraries\STM32L0xx_HAL_LIB\inc;..\SRC\Libraries\STM32L0xx_HAL_LIB\CMSIS;..\SRC\LIB_Config;..\SRC\PF_Config;..\SRC\USER;..\SRC\Libraries\FATFS;..\SRC\Libraries\SD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ../SRC/USER/: main.c fatfs_storage.c
  group PF_Config
    ../SRC/PF_Config/: PF_Config.c
  group LIB_Config
    ../SRC/LIB_Config/: LIB_Config.h MacroAndConst.h
  group Hardware
    ../SRC/Libraries/Fonts/: Fonts.c
    ../SRC/Libraries/LCD/: LCD.c
    ../SRC/Libraries/SPI/: SPI.c
    ../SRC/Libraries/SD/: MMC_SD.C
  group STM32L0xx_HAL_LIB
    ../SRC/Libraries/STM32L0xx_HAL_LIB/CMSIS/: system_stm32l0xx.c startup_stm32l053xx.s
    ../SRC/Libraries/STM32L0xx_HAL_LIB/src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c
  group FATFS
    ../SRC/Libraries/FATFS/: diskio.c ff.c
