# Keil uVision project ShowImage.uvproj, settings and files
target ShowImage (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ShowImage +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SRC\Libraries\Delay;..\SRC\Libraries\Fonts;..\SRC\Libraries\LCD;..\SRC\Libraries\SPI;..\SRC\Libraries\STM32F10x_LIB\inc;..\SRC\Libraries\STM32F10x_LIB\CMSIS;..\SRC\LIB_Config;..\SRC\PF_Config;..\SRC\USER;..\SRC\Libraries\SD;..\SRC\Libraries\USART;..\SRC\Libraries\FATFS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../SRC/USER/: main.c stm32f10x_it.c fatfs_storage.c
  group PF_Config
    ../SRC/PF_Config/: PF_Config.c
  group LIB_Config
    ../SRC/LIB_Config/: LIB_Config.h MacroAndConst.h
  group Hardware
    ../SRC/Libraries/Delay/: delay.c
    ../SRC/Libraries/Fonts/: Fonts.c
    ../SRC/Libraries/LCD/: LCD.c
    ../SRC/Libraries/SPI/: SPI.c
    ../SRC/Libraries/SD/: MMC_SD.C
    ../SRC/Libraries/USART/: USART.c
  group STM32F10x_LIB
    ../SRC/Libraries/STM32F10x_LIB/CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
    ../SRC/Libraries/STM32F10x_LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group fatfs
    ../SRC/Libraries/FATFS/: diskio.c ff.c
