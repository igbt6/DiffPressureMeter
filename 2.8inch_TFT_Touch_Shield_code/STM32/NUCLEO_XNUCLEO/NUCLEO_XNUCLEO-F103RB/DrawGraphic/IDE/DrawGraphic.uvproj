# Keil uVision project DrawGraphic.uvproj, settings and files
target DrawGraphic (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DrawGraphic
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\DisplayString\SRC\Libraries\Delay;..\..\DisplayString\SRC\Libraries\Fonts;..\..\DisplayString\SRC\Libraries\LCD;..\SRC\Libraries\SPI;..\..\DisplayString\SRC\Libraries\STM32F10x_LIB\inc;..\..\DisplayString\SRC\LIB_Config;..\SRC\PF_Config;..\SRC\USER
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../SRC/USER/: main.c stm32f10x_it.c
  group PF_Config
    ../SRC/PF_Config/: PF_Config.c
  group LIB_Config
    ../SRC/LIB_Config/: LIB_Config.h MacroAndConst.h
  group Hardware
    ../SRC/Libraries/Delay/: delay.c
    ../SRC/Libraries/Fonts/: Fonts.c
    ../SRC/Libraries/LCD/: LCD.c
    ../SRC/Libraries/SPI/: SPI.c
  group STM32F10x_LIB
    ../SRC/Libraries/STM32F10x_LIB/CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
    ../SRC/Libraries/STM32F10x_LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c
