# Keil uVision project DisplayString.uvproj, settings and files
target DisplayString (ARM-ADS)
  device: STM32L152RD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DisplayString
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_HD
  c include: ..\SRC\Libraries\Delay;..\SRC\Libraries\Fonts;..\SRC\Libraries\LCD;..\SRC\Libraries\SPI;..\SRC\LIB_Config;..\SRC\PF_Config;..\SRC\USER;..\SRC\Libraries\STM32L1xx_LIB\inc;..\SRC\Libraries\STM32L1xx_LIB\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../SRC/USER/: main.c
  group PF_Config
    ../SRC/PF_Config/: PF_Config.c
  group LIB_Config
    ../SRC/LIB_Config/: LIB_Config.h
  group Hardware
    ../SRC/Libraries/Fonts/: Fonts.c
    ../SRC/Libraries/LCD/: LCD.c
    ../SRC/Libraries/SPI/: SPI.c
    ../SRC/Libraries/Delay/: delay.c
  group STM32L1xx_LIB
    ../SRC/Libraries/STM32L1xx_LIB/CMSIS/: system_stm32l1xx.c startup_stm32l1xx_hd.s
    ../SRC/Libraries/STM32L1xx_LIB/src/: misc.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_spi.c stm32l1xx_syscfg.c
